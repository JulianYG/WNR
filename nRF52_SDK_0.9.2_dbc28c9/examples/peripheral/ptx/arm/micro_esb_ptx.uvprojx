# Keil uVision project micro_esb_ptx.uvprojx, settings and files
target nrf51822_xxaa (256K) (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.3.2
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: tiny_esb_ptx +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: NRF51
  c misc: --c99
  c include: ..\..\..\..\..\components\drivers_nrf\hal;..\..\common;C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.2.0\CMSIS;C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.2.0\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../: main.c
    ../../../../components/libraries/esb/: micro_esb.c
  group core
    ../../../../components/toolchain/: system_nrf51.c
    ../../../../components/toolchain/arm/: arm_startup_nrf51.s
target nrf51822_xxab (128K) (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.3.2
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: template_project_arm +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: NRF51
  c misc: --c99
  c include: ..\..\..\..\Include;..\..\..\..\components\drivers_nrf\delay;..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\components\libraries\esb;C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.2.0\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target nrf51822_xxaa_s110 (256K) (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.3.2
  cpu: as above
  output: template_project_arm +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: NRF51
  c misc: --c99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x14000 size 0x2b000
  memory RVCT9: RAM 0x20002000 size 0x2000
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  cpu: as above
  output: template_project_arm +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: NRF51
  c misc: --c99
  c include: ..\..\..\..\Include
  library: MicroLIB
  memory RVCT4: ROM 0x14000 size 0xb000
  memory RVCT9: RAM 0x20002000 size 0x2000
target nrf51822_xxaa_s120 (256K) (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.3.2
  cpu: as above
  output: template_project_arm +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: NRF51
  c misc: --c99
  c include: ..\..\..\..\Include;C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.2.0\CMSIS\Include;..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\components\libraries\esb;..\..\..\..\components\drivers_nrf\delay
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x27000
  memory RVCT9: RAM 0x20002800 size 0x1800
target nrf51822_xxab_s120 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  cpu: as above
  output: template_project_arm +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: NRF51
  c misc: --c99
  c include: ..\..\..\..\Include
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x7000
  memory RVCT9: RAM 0x20002800 size 0x1800
