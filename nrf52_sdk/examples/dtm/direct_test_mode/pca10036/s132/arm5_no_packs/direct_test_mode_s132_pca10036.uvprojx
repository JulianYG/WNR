# Keil uVision project direct_test_mode_s132_pca10036.uvprojx, settings and files
target nrf52832_xxaa (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.3.2
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1
  c define: BSP_DEFINES_ONLY BOARD_PCA10036 CONFIG_GPIO_AS_PINRESET S132 NRF52 SOFTDEVICE_PRESENT
  c misc: --c99
  c include: ..\..\..;..\..\..\..\..\bsp;..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\components\ble\ble_dtm;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\components\drivers_nrf\hal
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x61000
  memory RVCT9: RAM 0x20002800 size 0x5800
  group Application
    ../../../: main.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_BLE
    ../../../../../../components/ble/ble_dtm/: ble_dtm.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/s132/doc/: s132_nrf52_1.0.0-3.alpha_licence_agreement.txt
software components: CMSIS:CORE 3.40.0, Device:Startup 8.0.3
